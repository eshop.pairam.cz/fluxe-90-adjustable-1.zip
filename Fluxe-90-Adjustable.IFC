Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Fluxe-90-Adjustable_Scurion-Adjustable.IFC
Time: 2016-10-31T12:44:34
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Fluxe-90-Adjustable_Scurion-Adjustable
In: Default Storey
Material: Steel
PSet_Type_Identity_Data - OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights
PSet_Mass_Property - Mass Measure: 265.975; Area Measure: 33781.2 m2; Volume Measure: 265975 m3
